Commit message: hacks... so many hacks

File: ragnar_support/urdf/ragnar2.urdf (robot description, URDF)
Before this commit: robot Ragnar, 16 links, 15 joints
Links:
- added link world
Joints:
- added joint world_to_base: type fixed, parent world, child base_link
